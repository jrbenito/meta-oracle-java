PV_UPDATE = "60"
BUILD_NUMBER = "19"

require oracle-jse-ejre.inc

SRC_URI = "http://download.oracle.com/otn/java/ejre/7u${PV_UPDATE}-b${BUILD_NUMBER}/ejre-7u${PV_UPDATE}-fcs-b${BUILD_NUMBER}-linux-arm-vfp-hflt-client_headless-07_may_2014.tar.gz"

SRC_URI[md5sum] = "b9b8f598b0a7f49e4d221f16ba25c6c0"
SRC_URI[sha256sum] = "ed061060011d88efe5563c2949c00993db85db17ab94f18a78713007a2b90faf"
