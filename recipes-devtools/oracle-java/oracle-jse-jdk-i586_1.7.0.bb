require oracle-jse-jdk.inc

PR = "r0"
PV_UPDATE = "02"

SRC_URI = "http://download.oracle.com/otn-pub/java/jdk/7u2-b13/jdk-7u2-linux-i586.tar.gz"

SRC_URI[md5sum] = "8a06141ffae6c96743ea405b75e54f84"
SRC_URI[sha256sum] = "74faad48fef2c368276dbd1fd6c02520b0e9ebdcb1621916c1af345fc3ba65d1"
