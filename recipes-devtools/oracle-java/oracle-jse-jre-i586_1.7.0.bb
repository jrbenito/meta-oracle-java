PR = "r0"
PV_UPDATE = "25"

require oracle-jse-jre.inc

SRC_URI = "http://download.oracle.com/otn-pub/java/jdk/7u25-b15/jre-7u25-linux-i586.tar.gz"

SRC_URI[md5sum] = "0e9ccefe49e937e592dbb605f2e8e7d8"
SRC_URI[sha256sum] = "4016965536d8607743267812ab04e6d428036dda432893748c1df6cb77b09628"
